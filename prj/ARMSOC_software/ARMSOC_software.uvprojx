# Keil uVision project ARMSOC_software.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ARMSOC_software +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  c include: .\include;.\TTS;.\OLED;.\ucosii\config;.\ucosii\port;.\ucosii\source
  memory RVCT4: ROM 0x0 size 0x3fff
  memory RVCT9: RAM 0x20004000 size 0x3fff
  link misc: --entry Reset_Handler
  group include
    ./include/: UART.h gpio.h IR.h systick.h
  group app
    ./src/: main.h main.c ds18b20.c
    ./TTS/: SYN6288.C
    ./OLED/: drive.c
  group driver
    ./src/: ARMSOC.s gpio.c systick.c UART.c
  group uCOS
    ./ucosii/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ./ucosii/port/: os_cpu_a_keil.asm os_cpu_c_keil.c os_dbg_keil.c
